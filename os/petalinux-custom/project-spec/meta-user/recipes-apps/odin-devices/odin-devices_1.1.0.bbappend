# Temporary modification added to force support for LTC2986 before it is present in
# the main branch.
SRC_URI = "git://git@github.com/stfc-aeg/odin-devices.git;protocol=ssh;branch=add-ltc2986"

# Set revision to commit hash. Update manually when satisfied with compatibility
SRCREV = "ca6868b4b3ae0c337f90a78d6d70df0fa4db2f50"
