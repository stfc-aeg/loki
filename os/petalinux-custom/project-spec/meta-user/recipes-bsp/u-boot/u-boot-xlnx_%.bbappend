FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " file://platform-top.h \
            file://user_2025-03-04-15-07-00.cfg \
            "
