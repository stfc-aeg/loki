SRCREV = "92d6a35f3d8d721cda7d6fe664b435311dd368b4"
PV = "0.23+git${SRCPV}"
