FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-removed-CS-inversion.patch \
            file://devtool-fragment.cfg \
            "

