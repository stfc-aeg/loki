SUMMARY = "Python pyfdt library for dealing with flattened device trees"
HOMEPAGE = "https://pypi.org/project/pyfdt/"
LICENSE = "CLOSED"

PYPI_PACKAGE = "pyfdt"

PV = "0.3"
SRC_URI[md5sum] = "b8b81d0770253cd1843248bb754b5979"

inherit pypi setuptools3